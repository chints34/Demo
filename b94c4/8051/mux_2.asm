$INCLUDE(DELAY.ASM)
$INCLUDE(SEG_MUX.ASM)
CSEG AT 0
MAIN:
MOV DPTR,#SEG_LUT
MOV R4,#45
AGAIN:
ACALL DISP_2_MUX_SEGS
SJMP AGAIN


DISP_2_MUX_SEGS:
MOV A,R4
MOV B,#10
DIV AB
MOVC A,@A+DPTR
ORL A,#80H
MOV SEG_2_MUX,A
CLR SEL1
ACALL DELAY1MS
ACALL DELAY1MS
ACALL DELAY1MS
SETB SEL1


MOV A,B
MOVC A,@A+DPTR
ORL A,#80H
MOV SEG_2_MUX,A
CLR SEL2
ACALL DELAY1MS
ACALL DELAY1MS
ACALL DELAY1MS
SETB SEL2

RET

END
