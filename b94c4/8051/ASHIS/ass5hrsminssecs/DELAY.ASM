DELAY_ROUTINES SEGMENT CODE
RSEG DELAY_ROUTINES

;SUBROUTINE BLOCK

DELAY1MS:
MOV R7,#255
DJNZ R7,$

MOV R7,#242
DJNZ R7,$
RET

DELAY100MS:
MOV R6,#99
L1:
ACALL DELAY1MS
DJNZ R6,L1

MOV R6,#255
DJNZ R6,$

MOV R6,#142
DJNZ R6,$

NOP

RET

DELAY1S:
MOV R5,#9
L2:
ACALL DELAY100MS
DJNZ R5,L2
MOV R5,#99
L3:
ACALL DELAY1MS
DJNZ R5,L3
MOV R5,#255
DJNZ R5,$

MOV R5,#133
DJNZ R5,$
RET
