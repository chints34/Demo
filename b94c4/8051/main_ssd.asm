$INCLUDE(DELAY.ASM)
SEVSEG SEGMENT CODE
RSEG SEVSEG
SEG_LUT:DB 40H;0
	DB 79H;1
	DB 24H;2
	DB 30H;3
	DB 19H;4
	DB 12H;5
	DB 02H;6
	DB 78H;7
 	DB 00H;8
SEG EQU P0
CSEG AT 0
MAIN:
MOV DPTR,#SEG_LUT
AGAIN:
CLR A
MOVC A,@A+DPTR
MOV SEG,A
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
INC DPTR
MOV A,DPL
CJNE A,#SEG_LUT+10,AGAIN
SJMP MAIN
END
