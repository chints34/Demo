$INCLUDE(DELAY.ASM)
LEDS EQU P2
LED_LUT SEGMENT CODE
RSEG LED_LUT
LUT:DB 0EH
    DB 0DH
    DB 0BH
    DB 07H
    DB 1FH
    DB 2FH
    DB 4FH 
    DB 8FH

CSEG AT 0
MAIN:
MOV LEDS,#0FH
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
MOV DPTR,#LUT
AGAIN:
CLR A
MOVC A,@A+DPTR
MOV LEDS,A
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
INC DPTR
MOV A,DPL
CJNE A,#LUT+8,AGAIN
MOV LEDS,#0FH
ACALL DELAY100MS
ACALL DELAY100MS
ACALL DELAY100MS
MOV A,#0A5H
AGAIN1:
MOV LEDS,A
ACALL DELAY100MS
CPL A
SJMP AGAIN1
END
